options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 2.3e9
    step: 100e6
    stop: 2.6e9
    value: 2.5e9
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 10e3
    stop: 100e6
    value: '5000'
  states: {state: disabled}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '100'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 10e3
    stop: 100e3
    value: '500'
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e2
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_correctiq_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
