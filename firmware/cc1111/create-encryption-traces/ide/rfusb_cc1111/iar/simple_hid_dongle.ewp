# IAR project simple_hid_dongle.ewp, settings and files
configuration rfusb_cc1111 (8051, debug)
  General.OGChipSelectMenu: CC1111F32 CC1111F32
  ICC8051.CCDefines: MRFI_CC1111; MCU_H="ioCC1111.h"; MRFI; MRFI_MAX_PAYLOAD_SIZE=53; MAX_HOPS=1; chip=1111; BSP_CONFIG_CLOCK_MHZ=24
  ICC8051.CCDiagSuppress: Pe001,Pa082,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/apps/simple_hid; ../../../source/Components/SimpliciTI/mrfi; ../../../source/Components/SimpliciTI/bsp; ../../../source/Components/SimpliciTI/bsp/drivers; ../../../source/Components/SimpliciTI/bsp/boards/rfusb; ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/common/cc8051; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/components/radios/ccxx10; ../../../source/Components/targets/ccxx11_dongle; ../../../source/Components/usb/library; ../../../source/Components/usb/class_hid
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=1111
  XLINK.XclFile: C:\Users\tomca\Desktop\working IAR\ide\rfusb_cc1111\iar\lnk51ew_cc1111.xcl
  group application
    ../../../source/apps/simple_hid/: aes.c aes.h rxtest.c
  group application/common
    ../../../source/apps/simple_hid/: ioCCxx10_bitdef.h
