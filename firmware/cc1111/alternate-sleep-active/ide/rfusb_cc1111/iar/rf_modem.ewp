# IAR project rf_modem.ewp, settings and files
configuration rfusb_cc1111 (8051, debug)
  General.OGChipSelectMenu: CC1111F32 CC1111F32
  ICC8051.CCDefines: BUF_SIZE=192; USB_UART; MRFI_CC1111; MCU_H="ioCC1111.h"; MRFI; MRFI_MAX_PAYLOAD_SIZE=53; MAX_HOPS=1; chip=1111; BSP_CONFIG_CLOCK_MHZ=24
  ICC8051.CCDiagSuppress: Pe001,Pa082,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/SimpliciTI/mrfi; ../../../source/Components/SimpliciTI/bsp; ../../../source/Components/SimpliciTI/bsp/drivers; ../../../source/Components/SimpliciTI/bsp/boards/rfusb; ../../../source/Components/utils; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common; ../../../source/Components/common/cc8051; ../../../source/Components/targets/common; ../../../source/components/radios/ccxx10; ../../../source/Components/targets/ccxx11_dongle; ../../../source/Components/usb/library; ../../../source/Components/usb/class_cdc; ..\..\..\source\components\encryption; ..\..\..\source\components\tiny-aes-c; $TOOLKIT_DIR$\inc\dlib\c
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=1111
  XLINK.XclFile: lnk51ew_cc1111.xcl
  group application
    ../../../source/apps/rf_modem/: rf_modem.c
  group application/common
    ../../../source/apps/common/: ioCCxx10_bitdef.h mrfi_link.c mrfi_link.h
  group encryption
    ../../../source/components/encryption/: aes_coprocessor.h
  group hal/common
    ../../../source/components/common/cc8051/: adc.c adc.h hal_cc8051.h
    ../../../source/components/common/: hal_defs.h hal_int.c hal_types.h
  group hal/common/io
    ../../../source/components/targets/common/: hal_lcd_dummy.c hal_uart_usb.c
  group hal/interface
    ../../../source/components/targets/interface/: hal_assert.h hal_button.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h hal_rf.h hal_timer_32k.h hal_uart.h
  group hal/radio/ccxx10
    ../../../source/components/radios/ccxx10/: clock.c clock.h hal_mcu.c hal_timer_32k.c
  group hal/rfusb
    ../../../source/components/targets/ccxx11_dongle/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_led.c
  group mrfi
    ../../../source/components/simpliciti/mrfi/: mrfi.c mrfi.h mrfi_defs.h
    ../../../source/components/simpliciti/mrfi/smartrf/cc1111/: smartrf_cc1111.h
  group mrfi/bsp
    ../../../source/components/simpliciti/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../source/components/simpliciti/bsp/mcus/: bsp_8051_defs.h
    ../../../source/components/simpliciti/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
    ../../../source/components/simpliciti/bsp/drivers/: bsp_buttons.h bsp_leds.h
  group mrfi/bsp/rfusb
    ../../../source/components/simpliciti/bsp/boards/rfusb/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
    ../../../source/components/simpliciti/bsp/boards/rfusb/bsp_external/: mrfi_board_defs.h
  group tinyaes
    ../../../source/components/tiny-aes-c/: aes.c aes.h
  group usb/class_cdc
    ../../../source/components/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h usb_uart.c usb_uart.h
  group usb/library
    ../../../source/components/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group usb/library/ccxx11
    ../../../source/components/usb/library/ccxx11/: usb_interrupt.c usb_suspend.c
  group utilities
    ../../../source/components/utils/: util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h util_uart.c util_uart.h
